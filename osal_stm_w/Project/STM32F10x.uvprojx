# Keil uVision project STM32F10x.uvprojx, settings and files
target STM32F10x (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,__KEIL__
  c include: .\;..\core\inc;..\bsp\inc;..\hal\inc;..\osal\inc;..\driver\inc;..\comm\inc;..\functions\inc;..\BootLoader\inc;..\Application\inc
  library: MicroLIB
  memory RVCT4: ROM 0x800d000 size 0x43000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../Core/startup/: startup_stm32f10x_hd.s
  group core
    ../Core/src/: core_cm3.c cortexm3_macro.s
  group bsp
    ../bsp/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hal
    ../hal/src/: hal_adc.c hal_cpu.c hal_crc.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iap.c hal_spi.c hal_timer.c hal_uart.c hal_rtc.c
  group osal
    ../osal/src/: osal.c osal_error.c osal_sock.c osal_task.c osal_time.c osal_router.c
  group driver
    ../driver/src/: w25x16.c esp8266.c
  group comm
    ../comm/src/: can.c comm.c comm2.c comm3.c comm4.c comm5.c comm_esp8266.c
  group functionts
    ../functions/src/: updateunit.c debugunit.c
  group bootloader
    ../BootLoader/src/: bootloader.c
  group application
    ../Application/src/: application.c global.c
software components: CMSIS:CORE 5.0.0
